# Keil uVision project project.uvprojx, settings and files
target N32G43x (6160000::V6.16::ARMCLANG)
  device: N32G430G8Q7 Nationstech
  pack: Nationstech.N32G430_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32G43X, USE_STDPERIPH_DRIVER
  c include: ..\..\firmware\CMSIS\device;..\..\firmware\CMSIS\core;..\..\firmware\n32g430_std_periph_driver\inc;..\inc;..\..\ThirdParty;..\..\ThirdParty\Check;..\..\ThirdParty\Diy;..\..\ThirdParty\List;..\..\ThirdParty\List\ListRing;..\..\ThirdParty\PID;..\..\ThirdParty\RealTimeTerminal;..\..\ThirdParty\RealTimeTerminal\RTT;..\..\common;..\..\App;..\..\App\Halt;..\..\App\Mop;..\..\App\IapMcuUpdata;..\..\App\IapTester;..\..\App\Standby;..\..\Bsp_N32g43x;..\..\Bsp_N32g43x\UART;..\..\Bsp_N32g43x\TIM;..\..\Bsp_N32g43x\Other;..\..\Drv;..\..\Drv\Iap;..\..\Thread;..\..\Drv\fan;..\..\Drv\heater;..\..\Drv\monitor;..\..\log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../firmware/CMSIS/device/startup/: startup_n32g430.s
  group CMSIS
    ../../firmware/CMSIS/device/: system_n32g430.c
  group FWLB
    ../../firmware/n32g430_std_periph_driver/src/: n32g430_adc.c n32g430_dma.c n32g430_gpio.c n32g430_iwdg.c n32g430_rcc.c n32g430_tim.c n32g430_usart.c misc.c n32g430_exti.c
  group USER
    ../src/: main.c n32g430_it.c
  group THIRDPARTY
    ../../ThirdParty/Check/: Checksum.c CRC8.c CRC16.c
    ../../ThirdParty/Diy/: BinarySwitch.c Diy.c Number.c
    ../../ThirdParty/List/ListRing/: ListRing.c
    ../../ThirdParty/PID/: PID.c
    ../../ThirdParty/RealTimeTerminal/RTT/: RTT_FinSH.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Bsp
    ../../Bsp_N32g43x/: Bsp.c
    ../../Bsp_N32g43x/Other/: Boot.c DMA.c IO.c Mcu.c WDG.c sADC.c
  group Bsp/Tim
    ../../Bsp_N32g43x/TIM/: TIM2.c TIM3.c TIM4.c
  group Bsp/Uart
    ../../Bsp_N32g43x/UART/: UART.c USART1.c USART1_Rx.c USART1_Tx.c
  group Drv
    ../../Drv/: Drv.c
  group Drv/monitor
    ../../Drv/monitor/: monitor.c
  group Drv/Iap
    ../../Drv/Iap/: Iap.c Iap_Rx.c Iap_Tx.c
  group Drv/heater
    ../../Drv/heater/: brush_Heater.c
  group Drv/fan
    ../../Drv/fan/: brush_Fan.c
  group App
    ../../App/: App.c App_Event.c
    ../../App/IapTester/: IapTester.c
    ../../App/Mop/: Mop.c
    ../../App/Standby/: Standby.c
  group Thread
    ../../Thread/: UserMain.c
  group Log
    ../../log/: n32g43x_Platform.c debug.h
software components: RTOS:kernel 3.1.5
